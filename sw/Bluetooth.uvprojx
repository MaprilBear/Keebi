# Keil uVision project Bluetooth.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: BGM220PC22HNA Silicon Labs
  pack: SiliconLabs.GeckoPlatform_BGM22_DFP.4.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Bluetooth
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 4.3.0
