# Keil uVision project DIYKeyboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DIYKeyboard
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c usb_dev_keyboard.h
    ./inc/: startup.s Unified_Port_Init.c Unified_Port_Init.h LED.c LED.h Timer0A.h Timer0A.c SysTickInts.c SysTickInts.h
    ./lib/RGB/: RGB.c RGB.h
    ./src/: usb_dev_keyboard.c usb_keyb_structs.c usb_keyb_structs.h pin_map.h buttons.c uart.c buttons.h uart.h uartstdio.h uartstdio.c ustdlib.h ustdlib.c
  group New Group
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.2.0.295/usblib/rvmdk/: usblib.lib
